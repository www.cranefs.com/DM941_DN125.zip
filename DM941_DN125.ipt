# Autodesk Inventor part: DM941_DN125
## iProperties
Created: 2011-02
Part Number: DM941_DN125
Document SubType Name: Modeling
Designer: D Cole
Density: 1 g/cm^3
Author: D Cole
